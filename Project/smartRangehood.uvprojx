# Keil uVision project smartRangehood.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smartRangehood +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Core;..\Firmware\inc;..\Middleware\FreeRTOS\port\include;..\Middleware\FreeRTOS\port\RVDS\ARM_CM3;..\HAL\Inc;..\System\Inc;..\Drivers\Inc;..\Adapter\Sensor\Inc;..\Adapter\Key\Inc;..\Interface\Sensor;..\Interface\Key;..\Service\Sensor\Inc;..\Service\Key\Inc;..\Service\PID\Inc;..\Service\CRC32\Inc;..\APP_Task\Inc;..\APP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Middleware/FreeRTOS/Src
    ../Middleware/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/port
    ../Middleware/FreeRTOS/port/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group Firmware
    ../Firmware/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAL
    ../HAL/Src/: gpio.c i2c.c adc.c spi.c tim.c flash.c usart.c
  group System
    ../System/Src/: debug_log.c delay.c sys.c
  group Drivers
    ../Drivers/Src/: led.c key.c motor.c aht20.c mq2.c lcd.c at24cxx.c touch.c ctiic.c ft5206.c gt9147.c ott2001a.c GUI.c buzzer.c windspeed.c bootloader.c usart_driver.c
  group Adapter
    ../Adapter/Sensor/Src/: aht20_adp.c mq2_adp.c
    ../Adapter/Key/Src/: key_adp.c
  group Interface/Sensor
    ../Interface/Sensor/: sensor_interface.h sensor_types.h
  group Interface/Key
    ../Interface/Key/: key_interface.h key_types.h
  group Service/Sensor
    ../Service/Sensor/Src/: sensor_service.c
  group Service/Key
    ../Service/Key/Src/: key_service.c
  group Service/PID
    ../Service/PID/Src/: pid_service.c
  group Service/CRC32
    ../Service/CRC32/Src/: crc32_service.c
  group APPTask
    ../APP_Task/Src/: app_tasks.c
  group APP
    ../APP/Src/: main.c stm32f10x_it.c system_stm32f10x.c
    ../APP/Inc/: FreeRTOSConfig.h
